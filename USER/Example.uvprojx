# Keil uVision project Example.uvprojx, settings and files
target DEMO (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__FPU_PRESENT=1,__FPU_USED=1,ARM_MATH_CM4,__CC_ARM
  c include: ..\USER;..\FWLIB\inc;..\HARDWARE\inc;..\PERIPH\inc;..\CORE;..\ALGORITHM\inc;..\FreeRTOS\include;..\FreeRTOS;..\FreeRTOS\portable;..\MY_STOCK\inc;..\CONTROL\inc;..\USE_DEMO\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: system_stm32f4xx.c stm32f4xx_it.c main.c init.c free_rtos_test.c
  group HARDWARE
    ../HARDWARE/SPI/: drv_spi.c
    ../HARDWARE/SYSTICK/: drv_systick.c
    ../HARDWARE/UART/: drv_uart.c
    ../HARDWARE/I2C/: drv_i2c.c
    ../HARDWARE/TIMER/: drv_timer.c
    ../HARDWARE/GPIO/: drv_gpio.c
    ../HARDWARE/ADC/: drv_adc.c
    ../HARDWARE/CAN/: drv_can.c
  group PERIPH
    ../PERIPH/OLED/: bsp_oled.c oled_font.c
    ../PERIPH/LED/: bsp_led.c
    ../PERIPH/AD7190/: bsp_ad7190.c
    ../PERIPH/C6X0/: bsp_esc.c
    ../PERIPH/JOYSTICK/: bsp_joystick.c
    ../PERIPH/RoboModule/: bsp_robomodule.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group ALGORITHM
    ../ALGORITHM/DISTANCE/: distance.c
    ../ALGORITHM/PROTOCOL/: protocol.c
  group FreeRTOS_Core
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c FreeRTOSConfig.h
  group FreeRTOS_port
    ../FreeRTOS/portable/: heap_4.c port.c
  group Control
    ../CONTROL/: control_plate_connect.c control_plate_control.c control_plate_master.c control_plate_slave.c
    ../CONTROL/inc/: control_plate.h
  group STOCK
    ../MY_STOCK/: chassis.c moto_control.c pack_deal.c pid.c user_math.c
  group USE_DEMO
    ../USE_DEMO/: demo_moto.c
